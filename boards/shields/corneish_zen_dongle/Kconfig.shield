## boards/shields/corneish_zen_dongle/Kconfig.shield
```kconfig
config SHIELD_CORNEISH_ZEN_DONGLE
    def_bool $(shields_list_contains,corneish_zen_dongle)
```
